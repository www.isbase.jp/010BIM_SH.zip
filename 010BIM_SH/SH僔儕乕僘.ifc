Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-07-13T19:28:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - 代替 UI 17.21.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 13 19:28:00 2022 * Host: 023-KYOYA-02 * Database: C:\Users\kozo-keikaku\AppData\Local\Temp\{7D6B2E76-C316-4DB0-B7DE-B5B017AA6BFD}\ifc * Database version: 5507 * Database creation date: Wed Jul 13 19:27:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 13 19:27:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 13 19:27:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: SH151, ISベース_SH:SH151:24990
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH151
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH171, ISベース_SH:SH171:25131
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH171
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH172, ISベース_SH:SH172:25262
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH172
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH201, ISベース_SH:SH201:25139
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH201
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH202, ISベース_SH:SH202:25263
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH202
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH203, ISベース_SH:SH203:25284
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH203
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH204, ISベース_SH:SH204:25305
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH204
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH251, ISベース_SH:SH251:25147
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH251
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH252, ISベース_SH:SH252:25264
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH252
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH253, ISベース_SH:SH253:25285
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH253
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH254, ISベース_SH:SH254:25306
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH254
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH255, ISベース_SH:SH255:25327
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH255
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH301 (5)
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH301
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Name (ISベース_SH:SH301:...)
25155
32723
32748
32754
32762

# IfcBuildingElementProxy: SH351, ISベース_SH:SH351:25163
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH351
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH352, ISベース_SH:SH352:25266
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH352
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH353, ISベース_SH:SH353:25287
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH353
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH354, ISベース_SH:SH354:25308
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH354
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH355, ISベース_SH:SH355:25329
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH355
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH356, ISベース_SH:SH356:25350
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH356
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH401, ISベース_SH:SH401:25173
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH401
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH402, ISベース_SH:SH402:25267
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH402
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH403, ISベース_SH:SH403:25288
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH403
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH404, ISベース_SH:SH404:25309
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH404
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH405, ISベース_SH:SH405:25330
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH405
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH406, ISベース_SH:SH406:25351
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH406
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH451, ISベース_SH:SH451:25181
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH451
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH452, ISベース_SH:SH452:25268
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH452
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH453, ISベース_SH:SH453:25289
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH453
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH454, ISベース_SH:SH454:25310
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH454
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH455, ISベース_SH:SH455:25331
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH455
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH456, ISベース_SH:SH456:25352
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH456
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH501, ISベース_SH:SH501:25189
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH501
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH502, ISベース_SH:SH502:25269
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH502
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH503, ISベース_SH:SH503:25290
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH503
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH504, ISベース_SH:SH504:25311
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH504
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH505, ISベース_SH:SH505:25332
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH505
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH506, ISベース_SH:SH506:25353
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH506
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH551, ISベース_SH:SH551:25197
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH551
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH552, ISベース_SH:SH552:25270
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH552
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH553, ISベース_SH:SH553:25291
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH553
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH554, ISベース_SH:SH554:25312
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH554
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH555, ISベース_SH:SH555:25333
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH555
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH556, ISベース_SH:SH556:25354
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH556
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH601, ISベース_SH:SH601:25205
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH601
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH602, ISベース_SH:SH602:25271
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH602
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH603, ISベース_SH:SH603:25292
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH603
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH604, ISベース_SH:SH604:25313
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH604
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH605, ISベース_SH:SH605:25334
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH605
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH606, ISベース_SH:SH606:25355
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH606
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH651, ISベース_SH:SH651:25215
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH651
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH652, ISベース_SH:SH652:25272
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH652
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH653, ISベース_SH:SH653:25293
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH653
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH654, ISベース_SH:SH654:25314
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH654
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH655, ISベース_SH:SH655:25335
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH655
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH701, ISベース_SH:SH701:25223
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH701
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH702, ISベース_SH:SH702:25273
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH702
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH703, ISベース_SH:SH703:25294
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH703
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH704, ISベース_SH:SH704:25315
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH704
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH705, ISベース_SH:SH705:25336
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH705
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH751, ISベース_SH:SH751:25231
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH751
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH752, ISベース_SH:SH752:25274
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH752
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH753, ISベース_SH:SH753:25295
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH753
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH754, ISベース_SH:SH754:25316
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH754
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH755, ISベース_SH:SH755:25337
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH755
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH801, ISベース_SH:SH801:33011
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH801
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH802, ISベース_SH:SH802:33012
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH802
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH803, ISベース_SH:SH803:33013
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH803
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH804, ISベース_SH:SH804:33014
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH804
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社

# IfcBuildingElementProxy: SH805, ISベース_SH:SH805:33015
In: レベル 1
Type - Material: コンクリート、モルタル
Pset_BuildingElementProxyCommon - Reference: SH805
Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
